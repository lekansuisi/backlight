## config/boards/shields/c1_mirror97/Kconfig.defconfig
```kconfig
if SHIELD_C1_MIRROR97

config ZMK_KEYBOARD_NAME
    default "C1 Mirror97 RGB"

endif
```
